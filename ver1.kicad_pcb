# Repository ledalert/has-garden_control-hw

## KiCad design ver1.kicad_pcb

Parts:
C1: 220µF 16V; c_elec_6.3x7.7; Mouser 647-UUR1C221MCL6GS
C2, C3, C4, C9: 1µF; SMD-0603_c
C5, C6, C7, C8: 100nF; SMD-0603_c
C10: 10µF; SMD-1210
D1: DIODESCH; Diode-SMA_Standard
D3, D4: LED; LED-0603
H1, H2, H3, H4: CONN_1; Pin_Header_Straight_1x01
P1: CONN_2; bornier2
P2: CONN_6; b6b-ph-kl
R1, R2, R3: 10kΩ; SMD-0603_r
R4, R35: 0Ω; SMD-0603_r
R5: 1Ω; SMD-0603_r
R6, R7: R; SMD-0603_r
U1: MCP1790; SOT-223
U2: STM32F100C6; lqfp-48

Connections:
/BOOT1: R3.1, U2.20 (PB2/BOOT1)
/ESP8266 PTH Connector/CH_PD: U2.33 (USART1_RTS/TIM1_ETR/PA12); also elsewhere on the board
/ESP8266 PTH Connector/GPIO0: U2.37 (JTCK/SWCLK/PA14); also elsewhere on the board
/ESP8266 PTH Connector/GPIO2: U2.38 (JTDI/PA15); also elsewhere on the board
/ESP8266 PTH Connector/RST: U2.34 (JTMS/SWDIO/PA13); also elsewhere on the board
/ESP8266 PTH Connector/RXD: U2.12 (USART2_TX/ADC1_IN2/TIM2_CH3/TIM15_CH1/P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); also elsewhere on the board
/ESP8266 PTH Connector/TXD: U2.13 (USART2_RX/ADC1_IN3/TIM2_CH4/TIM15_CH2/P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); also elsewhere on the board
/PC Interface/DTR: P2.3, R2.1, U2.44 (BOOT0); also elsewhere on the board
/PC Interface/RTS: P2.2, R1.2, U2.7 (~NRST); also elsewhere on the board
/PC Interface/RX: P2.4, U2.30 (USART1_TX/TIM1_CH2/TIM15_BKIN/PA9); also elsewhere on the board
/PC Interface/TX: P2.5, U2.31 (USART1_RX/TIM1_CH3/TIM17_BKIN/PA10); also elsewhere on the board
/PC Interface/VCC_OUT: R35.2; also elsewhere on the board
/STATUS_LED: R7.2, U2.42 (PB6/I2C1_SCL/TIM16_CH1N)
/control/OUT_1: U2.29 (USART1_CK/MCO/TIM1_CH1/PA8); also elsewhere on the board
/control/OUT_2: U2.27 (PB14/TIM1_CH2N); also elsewhere on the board
/control/OUT_3: U2.28 (PB15/TIM1_CH3N/TIM15_CH1N); also elsewhere on the board
/control/OUT_4: U2.32 (USART1_CTS/TIM1_CH4/PA11); also elsewhere on the board
/control/OUT_5: U2.45 (PB8/TIM4_CH3/TIM16_CH1/CEC); also elsewhere on the board
/control/OUT_6: U2.46 (PB9/TIM4_CH4/TIM17_CH1); also elsewhere on the board
/sensors/GND_HEAT: R6.2; also elsewhere on the board
/sensors/HEAT_EN: U2.43 (PB7/I2C1_SDA/TIM17_CH1N); also elsewhere on the board
/sensors/SAMPLE1: U2.10 (WKUP/USART2_CTS/ADC1_IN0/TIM2_CH1_ETR/P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); also elsewhere on the board
/sensors/SAMPLE2: U2.11 (USART2_RTS/ADC1_IN1/TIM2_CH2/PA1); also elsewhere on the board
/sensors/SAMPLE3: U2.14 (SPI1_NSS/ADC1_IN4/USART2_CK/DAC1_OUT/PA4); also elsewhere on the board
/sensors/SAMPLE4: U2.15 (SPI1_SCK/ADC1_IN5/DAC2_OUT/PA5); also elsewhere on the board
/sensors/SAMPLE5: U2.16 (SPI1_MISO/ADC1_IN6/TIM3_CH1/PA6); also elsewhere on the board
/sensors/SAMPLE6: U2.17 (SPI1_MOSI/ADC1_IN7/TIM3_CH2/PA7); also elsewhere on the board
/sensors/SAMPLE7: U2.18 (PB0/ADC1_IN8/TIM3_CH3); also elsewhere on the board
/sensors/SAMPLE8: U2.19 (PB1/ADC1_IN9/TIM3_CH4); also elsewhere on the board
/sensors/VDD_A: C9.1, R5.1, U2.9 (VDDA); also elsewhere on the board
AGND: C9.2, R4.1, U2.8 (VSSA); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, H1.1, H2.1, H3.1, H4.1, P1.1, P2.1, R2.2, R3.2, R4.2, U1.2, U2.23 (VSS), U2.35 (VSS), U2.47 (VSS); also elsewhere on the board
unnamed: C2.1, D1.2 (K), U1.1
unnamed: D3.2 (K), R6.1
unnamed: D4.2 (K), R7.1
VCC: C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, D3.1 (A), D4.1 (A), P2.6, R1.1, R5.2, R35.1, U1.3, U2.24 (VDD), U2.36 (VDD), U2.48 (VDD); also elsewhere on the board
VDD: C1.1, C10.1, D1.1 (A), P1.2 (PM); also elsewhere on the board

Notes on the sheet:
Program
Power
TIM4 not present!
0.1
Indicators
Mount holes
5 and 6 will not have PWM on STM32F100C6
Denna delen skall fixas om
Todo: Fixa finkräm till VDD_A Kolla om andra filter behövs Kontrollera komponenter, en del har fel footprint bara för att få en överblick Man kan nog ha detta till generisk automation också Fast då får man slänga dit ingångsskydd

Parts:
C11, C12, C13, C14, C15: C; SMD-0603_c
D5, D6: LED; LED-0603
P3: USB_Micro_B; USB MICRO B
R8, R9, R10, R11, R12, R13: R; SMD-0603_r
U3: FT231X; qfn-20

Connections:
/PC Interface/DTR: U3.18 (DTR); also elsewhere on the board
/PC Interface/RTS: U3.19 (RTS); also elsewhere on the board
/PC Interface/RX: U3.1 (RXD); also elsewhere on the board
/PC Interface/TX: U3.17 (TXD); also elsewhere on the board
/PC Interface/VBUS: C15.1, P3.1 (VBUS), R8.2, R10.2, R11.2
/PC Interface/VCC_OUT: C13.1, U3.10 (3V3OUT), U3.20 (VCCIO); also elsewhere on the board
GND: C11.2, C12.2, C13.2, C14.2, C15.2, P3.5 (GND), P3.S (Shield), R9.1, U3.3 (GND), U3.13 (GND), U3.21 (GND); also elsewhere on the board
unnamed: C11.1, P3.2 (D-), R12.2
unnamed: C12.1, P3.3 (D+), R13.2
unnamed: D5.1 (A), R10.1
unnamed: D5.2 (K), U3.14 (CBUS1)
unnamed: D6.1 (A), R11.1
unnamed: D6.2 (K), U3.7 (CBUS2)
unnamed: R8.1, R9.2, U3.11 (RESET)
unnamed: R12.1, U3.9 (USBDM)
unnamed: R13.1, U3.8 (USBDP)
VCC: C14.1, U3.12 (VCC); also elsewhere on the board

Parts:
P4: CONN_4X2; Pin_Header_Straight_2x04

Connections:
/ESP8266 PTH Connector/CH_PD: P4.6; also elsewhere on the board
/ESP8266 PTH Connector/GPIO0: P4.3; also elsewhere on the board
/ESP8266 PTH Connector/GPIO2: P4.5; also elsewhere on the board
/ESP8266 PTH Connector/RST: P4.4; also elsewhere on the board
/ESP8266 PTH Connector/RXD: P4.1; also elsewhere on the board
/ESP8266 PTH Connector/TXD: P4.8; also elsewhere on the board
GND: P4.7; also elsewhere on the board
VCC: P4.2; also elsewhere on the board

Parts:
Q1: FET_N; SOT-23-GDS
R14: R; SMD-0603_r

Connections:
/sensors/GND_HEAT: Q1.D; also elsewhere on the board
/sensors/HEAT_EN: Q1.G, R14.1; also elsewhere on the board
GND: Q1.S, R14.2; also elsewhere on the board

Parts:
D7, D8, D9, D10, D11, D12: LED; LED-0603
K1, K2, K3, K4, K5, K6: CONN_3; bornier3
R23, R24, R25, R26, R27, R28: R; SMD-0603_r
U4: 74HC14; DHVQFN14

Connections:
/control/OUT_1: U4.1; also elsewhere on the board
/control/OUT_2: U4.3; also elsewhere on the board
/control/OUT_3: U4.5; also elsewhere on the board
/control/OUT_4: U4.9; also elsewhere on the board
/control/OUT_5: U4.11; also elsewhere on the board
/control/OUT_6: U4.13; also elsewhere on the board
/control/solenoid_out_1/LOAD_SINK: K1.2 (PM); also elsewhere on the board
/control/solenoid_out_1/LOAD_VDD: K1.1; also elsewhere on the board
/control/solenoid_out_2/LOAD_SINK: K2.2 (PM); also elsewhere on the board
/control/solenoid_out_2/LOAD_VDD: K2.1; also elsewhere on the board
/control/solenoid_out_3/LOAD_SINK: K3.2 (PM); also elsewhere on the board
/control/solenoid_out_3/LOAD_VDD: K3.1; also elsewhere on the board
/control/solenoid_out_4/LOAD_SINK: K4.2 (PM); also elsewhere on the board
/control/solenoid_out_4/LOAD_VDD: K4.1; also elsewhere on the board
/control/solenoid_out_5/LOAD_SINK: K5.2 (PM); also elsewhere on the board
/control/solenoid_out_5/LOAD_VDD: K5.1; also elsewhere on the board
/control/solenoid_out_6/LOAD_SINK: K6.2 (PM); also elsewhere on the board
/control/solenoid_out_6/LOAD_VDD: K6.1; also elsewhere on the board
GND: K1.3, K2.3, K3.3, K4.3, K5.3, K6.3, U4.7 (GND); also elsewhere on the board
unnamed: D7.1 (A), R23.2
unnamed: D7.2 (K), U4.2
unnamed: D8.1 (A), R24.2
unnamed: D8.2 (K), U4.4
unnamed: D9.1 (A), R25.2
unnamed: D9.2 (K), U4.6
unnamed: D10.1 (A), R26.2
unnamed: D10.2 (K), U4.8
unnamed: D11.1 (A), R27.2
unnamed: D11.2 (K), U4.10
unnamed: D12.1 (A), R28.2
unnamed: D12.2 (K), U4.12
VCC: R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, U4.14 (VCC); also elsewhere on the board

Parts:
C16, C17: C; SMD-0603_c
P5: CONN_4; b4b-ph-kl
R15: R; SMD-0603_r

Connections:
/sensors/GND_HEAT: P5.4; also elsewhere on the board
/sensors/SAMPLE1: C16.1, P5.1, R15.2; also elsewhere on the board
/sensors/VDD_A: R15.1; also elsewhere on the board
AGND: C16.2, P5.2; also elsewhere on the board
GND: C17.2; also elsewhere on the board
VDD: C17.1, P5.3; also elsewhere on the board

Parts of its further copies:
C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31: C; SMD-0603_c
P6, P7, P8, P9, P10, P11, P12: CONN_4; b4b-ph-kl
R16, R17, R18, R19, R20, R21, R22: R; SMD-0603_r

Connections of its further copies:
/sensors/GND_HEAT: P6.4, P7.4, P8.4, P9.4, P10.4, P11.4, P12.4; also elsewhere on the board
/sensors/SAMPLE2: C18.1, P6.1, R16.2; also elsewhere on the board
/sensors/SAMPLE3: C20.1, P7.1, R17.2; also elsewhere on the board
/sensors/SAMPLE4: C22.1, P8.1, R18.2; also elsewhere on the board
/sensors/SAMPLE5: C24.1, P9.1, R19.2; also elsewhere on the board
/sensors/SAMPLE6: C26.1, P10.1, R20.2; also elsewhere on the board
/sensors/SAMPLE7: C30.1, P12.1, R22.2; also elsewhere on the board
/sensors/SAMPLE8: C28.1, P11.1, R21.2; also elsewhere on the board
/sensors/VDD_A: R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1; also elsewhere on the board
AGND: C18.2, C20.2, C22.2, C24.2, C26.2, C28.2, C30.2, P6.2, P7.2, P8.2, P9.2, P10.2, P11.2, P12.2; also elsewhere on the board
GND: C19.2, C21.2, C23.2, C25.2, C27.2, C29.2, C31.2; also elsewhere on the board
VDD: C19.1, C21.1, C23.1, C25.1, C27.1, C29.1, C31.1, P6.3, P7.3, P8.3, P9.3, P10.3, P11.3, P12.3; also elsewhere on the board

Notes on the sheet:
Probe

Parts:
C32: 100nF 35V; SMD-0603_c
D13: DIODESCH; Diode-SMA_Standard
Q2: FET_N; SOT-23-GDS
R29: 10kΩ; SMD-0603_r

Connections:
/control/OUT_1: Q2.G, R29.1; also elsewhere on the board
/control/solenoid_out_1/LOAD_SINK: D13.2 (K), Q2.D; also elsewhere on the board
/control/solenoid_out_1/LOAD_VDD: C32.1; also elsewhere on the board
GND: C32.2, D13.1 (A), Q2.S, R29.2; also elsewhere on the board

Parts of its further copies:
C33, C34, C35, C36, C37: 100nF 35V; SMD-0603_c
D14, D15, D16, D17, D18: DIODESCH; Diode-SMA_Standard
Q3, Q4, Q5, Q6, Q7: FET_N; SOT-23-GDS
R30, R31, R32, R33, R34: 10kΩ; SMD-0603_r

Connections of its further copies:
/control/OUT_2: Q3.G, R30.1; also elsewhere on the board
/control/OUT_3: Q4.G, R31.1; also elsewhere on the board
/control/OUT_4: Q5.G, R32.1; also elsewhere on the board
/control/OUT_5: Q6.G, R33.1; also elsewhere on the board
/control/OUT_6: Q7.G, R34.1; also elsewhere on the board
/control/solenoid_out_2/LOAD_SINK: D14.2 (K), Q3.D; also elsewhere on the board
/control/solenoid_out_2/LOAD_VDD: C33.1; also elsewhere on the board
/control/solenoid_out_3/LOAD_SINK: D15.2 (K), Q4.D; also elsewhere on the board
/control/solenoid_out_3/LOAD_VDD: C34.1; also elsewhere on the board
/control/solenoid_out_4/LOAD_SINK: D16.2 (K), Q5.D; also elsewhere on the board
/control/solenoid_out_4/LOAD_VDD: C35.1; also elsewhere on the board
/control/solenoid_out_5/LOAD_SINK: D17.2 (K), Q6.D; also elsewhere on the board
/control/solenoid_out_5/LOAD_VDD: C36.1; also elsewhere on the board
/control/solenoid_out_6/LOAD_SINK: D18.2 (K), Q7.D; also elsewhere on the board
/control/solenoid_out_6/LOAD_VDD: C37.1; also elsewhere on the board
GND: C33.2, C34.2, C35.2, C36.2, C37.2, D14.1 (A), D15.1 (A), D16.1 (A), D17.1 (A), D18.1 (A), Q3.S, Q4.S, Q5.S, Q6.S, Q7.S, R30.2, R31.2, R32.2, R33.2, R34.2; also elsewhere on the board

Notes on the sheet:
This sheet could be hooked up with a 3 terminal output So you can feed in supply and hook up a solenoid or so

Board: 2 copper layers, 85.0 x 56.0 mm, 122 parts (0 on the bottom side), 71 nets.
